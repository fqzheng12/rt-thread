# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ES32F3696LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
