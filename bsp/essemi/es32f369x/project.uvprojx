# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ES32F3696LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: ES32F36xx
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;drivers;..\..\..\components\finsh;.;..\..\..\include;libraries\CMSIS\Device\EastSoft\ES32F36xx\Include;libraries\CMSIS\Include;libraries\ES32F36xx_ALD_StdPeriph_Driver\Include;.\CAN_protocol
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
    ./CAN_protocol/: can_bsp.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c drv_spi.c drv_i2c.c drv_can.c drv_adc.c drv_rtc.c drv_hwtimer.c drv_pwm.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    libraries/ES32F36xx_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dac.c ald_dma.c ald_ebi.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_i2s.c ald_iap.c ald_nand.c ald_nor_lcd.c ald_pis.c ald_pmu.c ald_qspi.c ald_rmu.c ald_rtc.c ald_rtchw.c ald_spi.c ald_sram.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usb.c ald_wdt.c utils.c
    libraries/CMSIS/Device/EastSoft/ES32F36xx/Startup/keil/: startup_es32f36xx.s
  group kernel_sample
    ./kernel-sample-0.1.0/: dynmem_sample.c event_sample.c idlehook_sample.c interrupt_sample.c memp_sample.c msgq_sample.c mutex_sample.c priority_inversion.c producer_consumer.c scheduler_hook.c semaphore_sample.c thread_sample.c timer_sample.c timeslice_sample.c
  group doc
    ./: readme.txt
